# Keil uVision project LanQiaoTemplate.uvproj, settings and files
target LanQiaoTemplate (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: LanQiaoTemplate +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\;.\App;.\BSP;.\Core;.\Devices;.\Drivers
  asm include: .\;.\App;.\BSP;.\Core;.\Devices;.\Drivers
  group Root
    ./: main.c
  group App
    ./App/: app.c app.h
  group BSP
    ./BSP/: bsp_board.c bsp_board.h bsp_led.c bsp_led.h bsp_beep_relay.c bsp_beep_relay.h bsp_seg.c bsp_seg.h bsp_key.c bsp_key.h bsp_uart.c bsp_uart.h bsp_tick.c bsp_tick.h
  group Drivers
    ./Drivers/: drv_iic.c drv_iic.h drv_onewire.c drv_onewire.h drv_ds1302.c drv_ds1302.h
  group Devices
    ./Devices/: dev_at24c02.c dev_at24c02.h dev_pcf8591.c dev_pcf8591.h dev_ds18b20.c dev_ds18b20.h dev_ds1302.c dev_ds1302.h dev_ultrasonic.c dev_ultrasonic.h dev_freq_counter.c dev_freq_counter.h
  group Core
    ./Core/: common.h STC15F2K60S2.h
